# Keil uVision project stm32-bootloader.uvprojx, settings and files
target Release (6140000::V6.14::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32-bootloader
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HSE_VALUE=8000000, STM32F407xx, _RTE_
  c include: .\include;.\source;..\..\drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\drivers\STM32F4xx_HAL_Driver\Inc;..\..\lib\fatfs;..\..\lib\stm32-bootloader;..\..\drivers\STM32F4xx_HAL_Driver\Config;..\..\drivers\CMSIS\Include;.\RTE\_Release
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./source/: main.c
    ../../lib/stm32-bootloader/: bootloader.c
  group drivers
    ./source/: stm32f4xx_it.c system_stm32f4xx.c bsp_driver_sd_stm32f4xx.c bsp_WS2812x.c LED_Serial.c
    ./startup/: startup_stm32f40_41xxx.s
  group hal
    ../../drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_cec.c stm32f4xx_hal.c stm32f4xx_hal_crc.c stm32f4xx_hal_adc.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dma.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_flash.c stm32f4xx_hal_eth.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dsi.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_hash.c stm32f4xx_hal_nor.c stm32f4xx_hal_mmc.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_nand.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_i2s.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pccard.c stm32f4xx_ll_lptim.c stm32f4xx_hal_irda.c stm32f4xx_hal_pcd.c stm32f4xx_ll_crc.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_rng.c stm32f4xx_ll_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rtc.c stm32f4xx_ll_adc.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_smbus.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_usart.c stm32f4xx_ll_exti.c stm32f4xx_ll_dma.c stm32f4xx_ll_dac.c stm32f4xx_ll_gpio.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_fmc.c stm32f4xx_ll_i2c.c stm32f4xx_ll_rcc.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_rng.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_rtc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group fs
    ./source/: fatfs.c sd_diskio.c
    ../../lib/fatfs/: diskio.c ff.c ff_gen_drv.c
    ../../lib/fatfs/option/: unicode.c
