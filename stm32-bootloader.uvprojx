# Keil uVision project stm32-bootloader.uvprojx, settings and files
target Release (6140000::V6.14::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32-bootloader +hex
  BeforeMake: .\projects\STM32F407-OWL\git.h.bat
  AfterMake: .\projects\STM32F407-OWL\git.h.bat clear
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: HSE_VALUE=8000000, STM32F407xx, _RTE_, USE_HAL_DRIVER, USE_USB_OTG_FS
  c include: .\lib\fatfs;.\lib\stm32-bootloader;.\drivers\STM32F4xx_HAL_Driver\Inc;.\projects\STM32F407-OWL\include;.\projects\STM32F407-OWL\source;.\projects\STM32F407-OWL\RTE;.\drivers\STM32F4xx_HAL_Driver\Config;.\projects\STM32F407-OWL\RTE\_Release;.\drivers\CMSIS\Device\ST\STM32F4xx\Include;.\drivers\CMSIS\Include;.\lib\fatfs\ff14\source;.\lib\fatfs\ff14_port;.\projects\STM32F407-OWL;.\lib\STM32_USB_Device_Library\Core\inc;.\lib\STM32_USB_Device_Library\Class\msc\inc;.\lib\STM32_USB_OTG_Driver\inc;.\projects\STM32F407-OWL\source\usb_user;.\lib\Debug
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./lib/stm32-bootloader/: bootloader.c
    ./projects/STM32F407-OWL/source/: main.c tea.c
  group bsp
    ./projects/STM32F407-OWL/source/: bsp_WS2812x.c stm32f4xx_it.c system_stm32f4xx.c bsp_driver_sd_stm32f4xx.c
    ./projects/STM32F407-OWL/startup/: startup_stm32f40_41xxx.s
  group drivers
    ./projects/STM32F407-OWL/source/: LED_Serial.c
  group fs
    ./lib/fatfs/ff14/source/: ff.c ff.h ffconf.h ffsystem.c ffunicode.c
  group stm32_hal
    ./drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sd.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_tim.c stm32f4xx_ll_spi.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group fs_port
    ./lib/fatfs/ff14_port/: diskio.c mmc_port.c testcases.c
  group usbd_lib
    ./lib/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group usbd_msc
    ./lib/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c usbd_storage_template.c
  group usb_driver
    ./lib/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_hcd.c usb_hcd_int.c usb_otg.c usb_bsp_template.c
  group usb_user
    ./projects/STM32F407-OWL/source/usb_user/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c usbd_conf.h usb_conf.h usbd_desc.h
